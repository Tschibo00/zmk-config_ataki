## config/boards/shields/ataki_130xe/Kconfig.defconfig
```kconfig
if SHIELD_ATAKI_130XE

config ZMK_KEYBOARD_NAME
    default "AtaKi_130XE"

endif
```
